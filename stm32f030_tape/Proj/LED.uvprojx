# Keil uVision project LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: LED
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;..\My_Lib\delay;..\My_Lib\LED;..\My_Lib\gpio;..\My_Lib\uart;..\My_Lib\adc
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c
  group ST_Lib
    ../ST_Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_usart.c stm32f0xx_exti.c stm32f0xx_adc.c
  group My_Lib
    ../My_Lib/LED/: led.c
    ../My_Lib/delay/: delay.c
    ../User/: code_input.c code_proc.c
    ../My_Lib/gpio/: board_gpio.c
    ../My_Lib/uart/: USART1.c
    ../My_Lib/adc/: board_adc.c
  group System
    ../System/startup/: startup_stm32f0xx_ld.s
    ../System/CMSIS/: core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
